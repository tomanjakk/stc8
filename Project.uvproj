# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000)
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c Delay.c GPIO.c NVIC.c UART.c UART_Isr.c MY_Config.h MY_Config.c Timer.c Timer_Isr.c STC8H_PWM.c STC8H_PWM_Isr.c
